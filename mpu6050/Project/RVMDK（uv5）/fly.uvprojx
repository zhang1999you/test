# Keil uVision project fly.uvprojx, settings and files
target Fly (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fly
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\..\User;..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS;..\..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f103xb.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h delay.c
    ../../User/usart/: bsp_debug_usart.c bsp_usart_blt.c
    ../../User/mpu6050/: mpu6050.c
    ../../User/iic/: bsp_hard_i2c.c bsp_soft_i2c.c
    ../../User/hc05/: bsp_hc05.c
    ../../User/oled/: OLED.c OLED_Data.c
    ../../User/timer/: Timer.c
    ../../User/motor/: Motor.c PWM.c Encoder.c
    ../../User/pid/: PID.c PID.h
